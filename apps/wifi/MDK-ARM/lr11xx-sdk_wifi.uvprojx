# Keil uVision project lr11xx-sdk_wifi.uvprojx, settings and files
target LR1120MB1DIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi_LR1120MB1DIS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx,NUCLEO_L476RG, LR11XX_DISABLE_WARNINGS
  c include: ..\..\common;..\..\..\shields\peripherals\external_supply;..\..\..\shields\peripherals\Leds;..\..\..\shields\peripherals\lis2de12;..\..\..\shields\interface;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\radio\lr11xx_driver\src;..\..\..\smtc_hal\inc;..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal;..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\radio\radio_drivers_hal\;..\..\..\smtc_hal\board;..\..\common\printers;..\wifi_scan;..\wifi_scan_country_code;..\wifi_scan_country_code_time_limit;..\wifi_scan_time_limit;..\..\wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Application/User
    ../../common/: apps_common.c
    ../: main_wifi.c wifi_result_printers.c
    ../wifi_scan/: wifi_scan.c
    ../wifi_scan_country_code/: wifi_scan_country_code.c
    ../wifi_scan_country_code_time_limit/: wifi_scan_country_code_time_limit.c
    ../wifi_scan_time_limit/: wifi_scan_time_limit.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_iwdg.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../../../host_driver/STMicroelectronics/STM32L4xx/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../shields/peripherals/external_supply/: external_supply.c
    ../../../shields/peripherals/Leds/: leds.c
    ../../../shields/peripherals/lis2de12/: lis2de12.c
  group radio_driver
    ../../../radio/lr11xx_driver/src/: lr11xx_bootloader.c lr11xx_crypto_engine.c lr11xx_driver_version.c lr11xx_gnss.c lr11xx_lr_fhss.c lr11xx_radio.c lr11xx_radio_timings.c lr11xx_regmem.c lr11xx_system.c lr11xx_wifi.c
  group smtc_hal
    ../../../smtc_hal/STMicroelectronics/STM32L4xx/src/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_lp_timer.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr_list.c smtc_hal_trace.c smtc_hal_uart.c smtc_hal_watchdog.c
  group radio_hal
    ../../../radio/radio_drivers_hal/: lr11xx_hal.c
  group shields
    ../../../shields/common/: lr11x0mb1xys_board.c
    ../../../shields/LR1110/LR1110MB1DxS/: lr1110mb1dxs_pa_pwr_cfg.c
    ../../../shields/LR1110/LR1110MB1GxS/: lr1110mb1gxs_pa_pwr_cfg.c
    ../../../shields/LR1120/LR1120MB1DxS/: lr1120mb1dxs_pa_pwr_cfg.c
    ../../../shields/LR1120/LR1120MB1GxS/: lr1120mb1gxs_pa_pwr_cfg.c
  group radio_driver_printers
    ../../common/printers/: lr11xx_bootloader_types_str.c lr11xx_crypto_engine_types_str.c lr11xx_gnss_types_str.c lr11xx_radio_types_str.c lr11xx_system_types_str.c lr11xx_types_str.c lr11xx_wifi_types_str.c
target LR1120MB1GIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1120MB1GIS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\..\common;..\..\..\shields\peripherals\external_supply;..\..\..\shields\peripherals\Leds;..\..\..\shields\peripherals\lis2de12;..\..\..\shields\LR1110\LR1110MB1LxKS\BSP\board;..\..\..\shields\interface;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Include;..\..\..\host_driver\STMicroelectronics\STM32L4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\host_driver\STMicroelectronics\STM32L4xx\hal_config;..\..\..\radio\lr11xx_driver\src;..\..\..\smtc_hal\inc;..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\smtc_modem_hal;..\..\..\smtc_hal\STMicroelectronics\STM32L4xx\inc;..\..\..\radio\radio_drivers_hal\;..\..\..\smtc_hal\board;..\..\common\printers;..\wifi_scan;..\wifi_scan_country_code;..\wifi_scan_country_code_time_limit;..\wifi_scan_time_limit;..\..\wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1120MB1DJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1120MB1DJS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1120MB1GJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1120MB1GJS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1110MB1DIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1110MB1DIS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1110MB1GIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1110MB1GIS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1110MB1DJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1110MB1DJS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1110MB1GJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: wifi_LR1110MB1GJS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.4.0
