# Keil uVision project lr11xx-sdk_rf_certification.uvprojx, settings and files
target LR1120MB1DIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER,LR1120MB1DIS
  c include: ..\..\..\..\common\inc;..\..\..\..\libs\smtc-hal-mcu\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Core\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Projects\STM32L476G-EVAL\templates\Inc;..\..\..\..\libs\smtc-shields\common\inc;..\..\..\..\libs\smtc-shields\lr11xx\inc;..\..\..\..\libs\smtc_dbpsk_driver\src;..\..\..\common;..\..\..\common\printers\;..\..\..\lr11xx_driver\src;..\territories; ..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ../../../../libs/smtc-hal-mcu-stm32l4/third_party/STM32CubeL4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Application/User
    ../../../common/: apps_common.c apps_version.c
    ../../../../common/src/: smtc_hal_dbg_trace.c smtc_shield_pinout_mapping.c common_version.c uart_init.c smtc_hal_button.c
    ../: main_rf_certification.c
    ../territories/: arib.c etsi.c fcc.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../libs/smtc-hal-mcu-stm32l4/third_party/STM32CubeL4/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_lptim.c stm32l4xx_ll_usart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_exti.c stm32l4xx_ll_utils.c
  group Drivers/CMSIS
    ../../../../libs/smtc-hal-mcu-stm32l4/third_party/STM32CubeL4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group radio_driver
    ../../../../lr11xx/lr11xx_driver/src/: lr11xx_bootloader.c lr11xx_crypto_engine.c lr11xx_driver_version.c lr11xx_gnss.c lr11xx_lr_fhss.c lr11xx_radio.c lr11xx_rttof.c lr11xx_radio_timings.c lr11xx_regmem.c lr11xx_system.c lr11xx_wifi.c
  group smtc_hal
    ../../../../libs/smtc-hal-mcu-stm32l4/src/: smtc_hal_mcu_gpio_stm32l4.c smtc_hal_mcu_rng_stm32l4.c smtc_hal_mcu_uart_stm32l4.c smtc_hal_mcu_timer_stm32l4.c smtc_hal_mcu_stm32l4.c smtc_hal_mcu_spi_stm32l4.c
  group radio_hal
    ../../../../lr11xx/common/: lr11xx_hal.c
  group shields
    ../../../../libs/smtc-shields/lr11xx/src/: smtc_shield_lr11xx_common.c smtc_shield_lr11x0_common.c smtc_shield_lr11x1_common.c smtc_shield_lr1110mb1dxs_common.c smtc_shield_lr1110mb1gxs_common.c smtc_shield_lr1110mb1dis.c smtc_shield_lr1110mb1djs.c smtc_shield_lr1110mb1gis.c smtc_shield_lr1110mb1gjs.c smtc_shield_lr1120mb1dxs_common.c smtc_shield_lr1120mb1gxs_common.c smtc_shield_lr1120mb1dis.c smtc_shield_lr1120mb1djs.c smtc_shield_lr1120mb1gis.c smtc_shield_lr1120mb1gjs.c smtc_shield_lr1121mb1dis.c smtc_shield_lr1121mb1gis.c smtc_shield_lr1110mb1ipddis.c smtc_shield_lr1120mb1ipddis.c smtc_shield_lr11x0mb1ipddis_common.c smtc_shield_lr1110mb1pis.c smtc_shield_lr1120mb1pis.c smtc_shield_lr11x0mb1pis_common.c
    ../../../../libs/smtc_dbpsk_driver/src/: smtc_dbpsk.c
  group radio_driver_printers
    ../../../common/printers/: lr11xx_bootloader_types_str.c lr11xx_crypto_engine_types_str.c lr11xx_gnss_types_str.c lr11xx_radio_types_str.c lr11xx_system_types_str.c lr11xx_types_str.c lr11xx_wifi_types_str.c
target LR1120MB1IPDDIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER,LR1120MB1IPDDIS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target LR1120MB1GIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG, LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER,LR1120MB1GIS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1120MB1PIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG, LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER,LR1120MB1PIS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../../../../libs/smtc-shields/lr11xx/src/: smtc_shield_lr1120mb1gis.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1120MB1DJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG, LR1120MB1DJS, LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\common\inc;..\..\..\..\libs\smtc-hal-mcu\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Core\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Projects\STM32L476G-EVAL\templates\Inc;..\..\..\..\libs\smtc-shields\common\inc;..\..\..\..\libs\smtc_dbpsk_driver\src;..\..\..\..\libs\smtc-shields\lr11xx\inc;..\..\..\common;..\..\..\common\printers\;..\..\..\lr11xx_driver\src;..\territories; ..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1120MB1GJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1120MB1GJS, LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1110MB1DIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1110MB1DIS,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1110MB1IPDDIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1110MB1IPDDIS,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1110MB1GIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1110MB1GIS,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1110MB1PIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1110MB1PIS,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../../../../libs/smtc-shields/lr11xx/src/: smtc_shield_lr1110mb1gis.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1110MB1DJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1110MB1DJS,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1110MB1GJS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,LR1110MB1GJS,LR11XX_DISABLE_WARNINGS,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1121MB1DIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32L476xx,NUCLEO_L476RG,LR1121MB1DIS,LR11XX_DISABLE_WARNINGS, LR11XX_DISABLE_HIGH_ACP_WORKAROUND
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
target LR1121MB1GIS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: as above
  output: rf_certification +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32L476xx,NUCLEO_L476RG,LR1121MB1GIS,LR11XX_DISABLE_WARNINGS, LR11XX_DISABLE_HIGH_ACP_WORKAROUND
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group left out of the first target's files
    ../../../../common/src/: smtc_hal_button.c
    ../common/: rf_certification_common.c rf_certification_radio_common.c
    ../territories/: arib.c etsi.c fcc.c
software components: CMSIS:CORE 5.4.0
